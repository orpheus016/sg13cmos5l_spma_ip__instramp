** sch_path: cace/templates/pgia_top/ac_gain.sch
**.subckt ac_gain
x1 VINP VINN VCM gain_sel[0] gain_sel[1] gain_sel[2] gain_sel[3] VOUT AVDD VPWR IBIAS_IA IBIAS_G1
+ IBIAS_G2 IBIAS_BUF AVSS VGND pgia_top
V_AVDD AVDD 0 {vdd}
V_AVSS AVSS 0 0
V_VPWR VPWR 0 {vdd}
V_VGND VGND 0 0
I_IA IBIAS_IA 0 {ib_ia}
I_BUF IBIAS_BUF 0 {ib_buf}
I_G1 AVDD IBIAS_G1 {ib_g1}
I_G2 AVDD IBIAS_G2 {ib_g2}
V_CM VCM 0 {vcm}
V_G0 gain_sel[0] 0 DC 0
V_G1 gain_sel[1] 0 DC 0
V_G2 gain_sel[2] 0 DC 0
V_G3 gain_sel[3] 0 DC 0
CL VOUT 0 {cl} m=1
RL VOUT 0 {rl} m=1
V_INP VINP VCM 0 AC 0.5
V_INN VINN VCM 0 AC -0.5
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param rl=CACE{rl}
.param vdd=CACE{vdd}
.param vcm=CACE{vcm}
.param ib_ia=CACE{ib_ia=4.2u}
.param ib_buf=CACE{ib_buf=1.4u}
.param ib_g1=CACE{ib_g1=1.0u}
.param ib_g2=CACE{ib_g2=1.0u}
.param gain_code=CACE{gain_code=0}





.control
set num_threads=CACE{jobs}
save all v(VOUT)

let code = CACE{gain_code=0}
let vdd = CACE{vdd}
let b0 = (code % 2 >= 1) ? vdd : 0
let b1 = (floor(code / 2) % 2 >= 1) ? vdd : 0
let b2 = (floor(code / 4) % 2 >= 1) ? vdd : 0
let b3 = (floor(code / 8) % 2 >= 1) ? vdd : 0
alter @v_g0[dc] = $&b0
alter @v_g1[dc] = $&b1
alter @v_g2[dc] = $&b2
alter @v_g3[dc] = $&b3

alter @v_inp[acmag] = 0.5
alter @v_inn[acmag] = -0.5

ac dec 20 0.1 100Meg

let gain_db = db(v(VOUT))
let phase_deg = cph(v(VOUT)) * 180 / pi

meas ac gain_1k find gain_db at=1k
meas ac ph_1k find phase_deg at=1k

let code_idx = (code <= 10 ? code : 0)
let target_db = 18.0618 + code_idx * 6.0206
let gain_err = gain_1k - target_db

let gain_3db = gain_1k - 3
let f_3db = 50e3
meas ac f_3db when gain_db = $&gain_3db fall=1

let f_0db = 10e6
meas ac f_0db when gain_db = 0 fall=1

let r_pseudo = 0.5 / (abs(i(v_inp)[0]) + 1e-18)
let cace_R_PSEUDO = r_pseudo

let cace_A_CL = gain_1k
let cace_A_ERR = gain_err
let cace_F3DB = f_3db
let cace_F0DB = f_0db
let cace_PH_1K = ph_1k

echo $&cace_A_CL $&cace_A_ERR $&cace_F3DB $&cace_F0DB $&cace_PH_1K $&cace_R_PSEUDO > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
