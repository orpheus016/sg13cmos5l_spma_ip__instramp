** sch_path: cace/templates/pgia_top/tran.sch
**.subckt tran
x1 VINP VINN VCM gain_sel[0] gain_sel[1] gain_sel[2] gain_sel[3] VOUT AVDD VPWR IBIAS_IA AVSS VGND
+ pgia_top
V_AVDD AVDD 0 {vdd}
V_AVSS AVSS 0 0
V_VPWR VPWR 0 {vdd}
V_VGND VGND 0 0
I_IA IBIAS_IA 0 {ib_ia}
V_CM VCM 0 {vcm}
V_G0 gain_sel[0] 0 DC 0
V_G1 gain_sel[1] 0 DC 0
V_G2 gain_sel[2] 0 DC 0
V_G3 gain_sel[3] 0 DC 0
CL VOUT 0 {cl} m=1
RL VOUT 0 {rl} m=1
V_INP VINP VCM 0 SIN(0 20u 10k 0 0 0)
V_INN VINN VCM 0 SIN(0 20u 10k 0 0 180)
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}
* std cells and decoder at top level (includes inside the DUT netlist are nested in the pgia_top
*+ subckt, invisible to the sub-blocks)
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice
.include /foss/designs/sg13cmos5l_spma_ip__instramp/gds/gain_decoder_4b/final/spice/gain_decoder_4b.spice

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param rl=CACE{rl}
.param vdd=CACE{vdd}
.param vcm=CACE{vcm}
.param ib_ia=CACE{ib_ia=4.2u}
.param gain_code=CACE{gain_code=0}





.control
set num_threads=CACE{jobs}
save all v(VOUT)

let code = CACE{gain_code=0}
let vdd = CACE{vdd}
let b0 = (code % 2 >= 1) ? vdd : 0
let b1 = (floor(code / 2) % 2 >= 1) ? vdd : 0
let b2 = (floor(code / 4) % 2 >= 1) ? vdd : 0
let b3 = (floor(code / 8) % 2 >= 1) ? vdd : 0
alter @v_g0[dc] = $&b0
alter @v_g1[dc] = $&b1
alter @v_g2[dc] = $&b2
alter @v_g3[dc] = $&b3

tran 100n 300u 100u
meas tran vpp pp v(VOUT) from=200u to=300u
let cace_VPP_OUT = vpp
let cace_EFF_GAIN = vpp / 40e-6

echo $&cace_VPP_OUT $&cace_EFF_GAIN > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
