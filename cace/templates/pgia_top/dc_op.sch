** sch_path: cace/templates/pgia_top/dc_op.sch
**.subckt dc_op
x1 VINP VINN VCM gain_sel[0] gain_sel[1] gain_sel[2] gain_sel[3] VOUT AVDD VPWR IBIAS_IA AVSS VGND
+ pgia_top
V_AVDD AVDD 0 {vdd}
V_AVSS AVSS 0 0
V_VPWR VPWR 0 {vdd}
V_VGND VGND 0 0
I_IA IBIAS_IA 0 {-ib_ia}
V_CM VCM 0 {vcm}
V_G0 gain_sel[0] 0 DC 0
V_G1 gain_sel[1] 0 DC 0
V_G2 gain_sel[2] 0 DC 0
V_G3 gain_sel[3] 0 DC 0
CL VOUT 0 {cl} m=1
RL VOUT 0 {rl} m=1
V_INP VINP VCM {vin_off}
V_INN VINN VCM 0
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}
* std cells and decoder at top level (includes inside the DUT netlist are nested in the pgia_top
*+ subckt, invisible to the sub-blocks)
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice
.include /foss/designs/sg13cmos5l_spma_ip__instramp/gds/gain_decoder_4b/final/spice/gain_decoder_4b.spice

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.options rshunt=1e12 gmin=1e-12 chgtol=1e-15 reltol=0.005





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param rl=CACE{rl}
.param vdd=CACE{vdd}
.param vcm=CACE{vcm}
.param ib_ia=CACE{ib_ia=1.0u}
.param gain_code=CACE{gain_code=0}
.param vin_off=CACE{vin_off=0}





.control
set num_threads=CACE{jobs}
save all v(VOUT) v(x1.v_ia) v(x1.v_stage1) v(x1.v_stage2)

let code = CACE{gain_code=0}
let vdd = CACE{vdd}
let b0 = (code % 2 >= 1) ? vdd : 0
let b1 = (floor(code / 2) % 2 >= 1) ? vdd : 0
let b2 = (floor(code / 4) % 2 >= 1) ? vdd : 0
let b3 = (floor(code / 8) % 2 >= 1) ? vdd : 0
alter @v_g0[dc] = $&b0
alter @v_g1[dc] = $&b1
alter @v_g2[dc] = $&b2
alter @v_g3[dc] = $&b3

op

let cace_V_IA = 0.6
let cace_V_ST1 = 0.6
let cace_V_ST2 = 0.6
let cace_V_IA = v(x1.v_ia)
let cace_V_ST1 = v(x1.v_stage1)
let cace_V_ST2 = v(x1.v_stage2)
let v_out = v(VOUT)
let i_avdd = -i(v_avdd)
let i_vpwr = -i(v_vpwr)
let i_tot = i_avdd + i_vpwr

let cace_VOS = abs(v_out - CACE{vcm})
let cace_VOUT = v_out
let cace_I_AVDD = i_avdd
let cace_I_VPWR = i_vpwr
let cace_IQ_TOT = i_tot
let cace_PWR = i_tot * CACE{vdd}

echo $&cace_VOS $&cace_V_IA $&cace_V_ST1 $&cace_V_ST2 $&cace_VOUT $&cace_I_AVDD $&cace_I_VPWR $&cace_IQ_TOT
+ $&cace_PWR > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
