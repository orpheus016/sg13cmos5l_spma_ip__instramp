** sch_path: cace/templates/gain_stage/tran_switch.sch
**.subckt tran_switch
x1 AVDD AVSS IBIAS VIN VCM VOUT s[0] s[1] s[2] s[3] s[4] gain_stage
V_AVDD AVDD 0 {vdd}
V_AVSS AVSS 0 0
V_VCM VCM 0 {vcm}
I_BIAS 0 IBIAS {ib}
V_IN VIN 0 DC {vcm} AC 1m
CL VOUT 0 {cl} m=1
V_S0 s[0] 0 0
V_S1 s[1] 0 0
V_S2 s[2] 0 0
V_S3 s[3] 0 0
V_S4 s[4] 0 0
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}
* std cells at top level (an include inside the DUT netlist is nested in the subckt and invisible to
*+ the sub-blocks)
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param ib=CACE{ib}
.param vdd=CACE{vdd}
.param vcm=CACE{vcm}
.param gain_tap=CACE{gain_tap=0}





.control
set num_threads=CACE{jobs}
save all

set vdd = CACE{vdd}

alter @v_s0 pulse = [ 0 $vdd 2u 10n 10n 2u 20u ]
alter @v_s1 pulse = [ 0 $vdd 4u 10n 10n 2u 20u ]
alter @v_s2[dc] = 0
alter @v_s3[dc] = 0
alter @v_s4[dc] = 0

let v_in_step = CACE{vcm} + 0.01
alter @v_in[dc] = $&v_in_step

tran 5n 8u

let v_baseline = CACE{vcm}
let v_glitch_peak = CACE{vcm}
meas tran v_glitch_peak max v(VOUT) from=1.9u to=2.5u
let v_glitch = abs(v_glitch_peak - $&v_baseline)

let v_settle_thresh = CACE{vcm} - 0.02
let t_settle = 2.5u
meas tran t_settle when v(VOUT)=$&v_settle_thresh cross=last from=2u to=6u
let t_settle_s = (t_settle > 2u ? (t_settle - 2u) : 0.5e-6)

let cace_V_GLITCH_MAX = v_glitch
let cace_T_SWITCH_SETTLE = t_settle_s

echo $&cace_V_GLITCH_MAX $&cace_T_SWITCH_SETTLE > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
