** sch_path: cace/templates/gain_stage/noise.sch
**.subckt noise
x1 AVDD AVSS IBIAS VIN VCM VOUT s[0] s[1] s[2] s[3] s[4] gain_stage
V_AVDD AVDD 0 {vdd}
V_AVSS AVSS 0 0
V_VCM VCM 0 {vcm}
I_BIAS 0 IBIAS {ib}
V_IN VIN 0 DC {vcm} AC 1m
CL VOUT 0 {cl} m=1
V_S0 s[0] 0 0
V_S1 s[1] 0 0
V_S2 s[2] 0 0
V_S3 s[3] 0 0
V_S4 s[4] 0 0
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param ib=CACE{ib}
.param vdd=CACE{vdd}
.param vcm=CACE{vcm}
.param gain_tap=CACE{gain_tap=0}





.control
set num_threads=CACE{jobs}
save all
destroy all

set tap = CACE{gain_tap=0}
set vdd = CACE{vdd}

alter @v_s0[dc] = 0
alter @v_s1[dc] = 0
alter @v_s2[dc] = 0
alter @v_s3[dc] = 0
alter @v_s4[dc] = 0

if ($tap = 1)
  alter @v_s0[dc] = $vdd
end
if ($tap = 2)
  alter @v_s1[dc] = $vdd
end
if ($tap = 3)
  alter @v_s2[dc] = $vdd
end
if ($tap = 4)
  alter @v_s3[dc] = $vdd
end
if ($tap = 5)
  alter @v_s4[dc] = $vdd
end

alter @v_in[acmag] = 1
noise v(VOUT) v_in dec 20 10 100MEG
alter @v_in[acmag] = 0

setplot noise1

let inoise_total_uv = noise2.inoise_total * 1e6
let onoise_total_uv = noise2.onoise_total * 1e6
let irn_nv = noise1.inoise_spectrum * 1e9
let orn_nv = noise1.onoise_spectrum * 1e9

let gain_lf = noise1.onoise_spectrum[0] / noise1.inoise_spectrum[0]
let inoise_eq_uv = onoise_total_uv / gain_lf

let irn_10 = irn_nv[0]
let irn_100 = irn_nv[20]
let irn_1k = irn_nv[40]
let irn_10k = irn_nv[60]

let cace_IRN_10 = irn_10 * 1e-9
let cace_IRN_100 = irn_100 * 1e-9
let cace_IRN_1K = irn_1k * 1e-9
let cace_IRN_10K = irn_10k * 1e-9
let cace_ORN_1K = orn_nv[40] * 1e-9
let cace_ONOISE_TOT = onoise_total_uv * 1e-6
let cace_INOISE_EQ = inoise_eq_uv * 1e-6

echo $&cace_IRN_10 $&cace_IRN_100 $&cace_IRN_1K $&cace_IRN_10K $&cace_ORN_1K $&cace_ONOISE_TOT $&cace_INOISE_EQ
+ > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
