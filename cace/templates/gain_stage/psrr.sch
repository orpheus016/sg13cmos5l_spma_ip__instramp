** sch_path: cace/templates/gain_stage/psrr.sch
**.subckt psrr
x1 AVDD AVSS IBIAS VIN VCM VOUT s[0] s[1] s[2] s[3] s[4] gain_stage
V_AVDD AVDD 0 {vdd}
V_AVSS AVSS 0 0
V_VCM VCM 0 {vcm}
I_BIAS 0 IBIAS {ib}
V_IN VIN 0 DC {vcm} AC 1m
CL VOUT 0 {cl} m=1
V_S0 s[0] 0 0
V_S1 s[1] 0 0
V_S2 s[2] 0 0
V_S3 s[3] 0 0
V_S4 s[4] 0 0
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}
* std cells at top level (an include inside the DUT netlist is nested in the subckt and invisible to
*+ the sub-blocks)
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param ib=CACE{ib}
.param vdd=CACE{vdd}
.param vcm=CACE{vcm}
.param gain_tap=CACE{gain_tap=0}





.control
set num_threads=CACE{jobs}
save all

set tap = CACE{gain_tap=0}
set vdd = CACE{vdd}

alter @v_s0[dc] = 0
alter @v_s1[dc] = 0
alter @v_s2[dc] = 0
alter @v_s3[dc] = 0
alter @v_s4[dc] = 0

if ($tap = 1)
  alter @v_s0[dc] = $vdd
end
if ($tap = 2)
  alter @v_s1[dc] = $vdd
end
if ($tap = 3)
  alter @v_s2[dc] = $vdd
end
if ($tap = 4)
  alter @v_s3[dc] = $vdd
end
if ($tap = 5)
  alter @v_s4[dc] = $vdd
end

alter @v_avdd[acmag] = 0
alter @v_in[acmag] = 1
ac dec 20 10 100MEG
let gain_in = db(v(VOUT))
let adm_dc = 0
meas ac adm_dc find gain_in at=10
set adm_val = $&adm_dc

alter @v_in[acmag] = 0
alter @v_avdd[acmag] = 1
ac dec 20 10 100MEG
let gain_vdd = db(v(VOUT))
let avdd_10 = -40
let avdd_100k = -40
let avdd_1meg = -40
meas ac avdd_10 find gain_vdd at=10
meas ac avdd_100k find gain_vdd at=100k
meas ac avdd_1meg find gain_vdd at=1MEG

let psrr_dc = $adm_val - avdd_10
let psrr_100k = $adm_val - avdd_100k
let psrr_1meg = $adm_val - avdd_1meg

let cace_PSRR_DC = psrr_dc
let cace_PSRR_100K = psrr_100k
let cace_PSRR_1M = psrr_1meg

echo $&cace_PSRR_DC $&cace_PSRR_100K $&cace_PSRR_1M > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
