** sch_path: cace/templates/gain_stage/dc_op.sch
**.subckt dc_op
x1 AVDD AVSS IBIAS VIN VCM VOUT s[0] s[1] s[2] s[3] s[4] gain_stage
V_AVDD AVDD 0 {vdd}
V_AVSS AVSS 0 0
V_VCM VCM 0 {vcm}
I_BIAS 0 IBIAS {ib}
V_IN VIN 0 DC {vcm} AC 1m
CL VOUT 0 {cl} m=1
V_S0 s[0] 0 0
V_S1 s[1] 0 0
V_S2 s[2] 0 0
V_S3 s[3] 0 0
V_S4 s[4] 0 0
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param ib=CACE{ib}
.param vdd=CACE{vdd}
.param vcm=CACE{vcm}
.param gain_tap=CACE{gain_tap=0}





.control
set num_threads=CACE{jobs}
save all

set tap = CACE{gain_tap=0}
set vdd = CACE{vdd}

alter @v_s0[dc] = 0
alter @v_s1[dc] = 0
alter @v_s2[dc] = 0
alter @v_s3[dc] = 0
alter @v_s4[dc] = 0

if ($tap = 1)
  alter @v_s0[dc] = $vdd
end
if ($tap = 2)
  alter @v_s1[dc] = $vdd
end
if ($tap = 3)
  alter @v_s2[dc] = $vdd
end
if ($tap = 4)
  alter @v_s3[dc] = $vdd
end
if ($tap = 5)
  alter @v_s4[dc] = $vdd
end

alter @v_in[acmag] = 0
alter @v_in[dc] = CACE{vcm}

op

let v_out = v(VOUT)
let v_cm = v(VCM)
let vos = v_out - v_cm
let i_q = -1 * i(v_avdd)
let p_q = -1 * i(v_avdd) * CACE{vdd}

let cace_VOS = vos
let cace_IQ = i_q
let cace_PWR = p_q
let cace_VOUT = v_out

echo $&cace_VOS $&cace_IQ $&cace_PWR $&cace_VOUT > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
