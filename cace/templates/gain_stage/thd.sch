** sch_path: cace/templates/gain_stage/thd.sch
**.subckt thd
x1 AVDD AVSS IBIAS VIN VCM VOUT s[0] s[1] s[2] s[3] s[4] gain_stage
V_AVDD AVDD 0 {vdd}
V_AVSS AVSS 0 0
V_VCM VCM 0 {vcm}
I_BIAS 0 IBIAS {ib}
V_IN VIN 0 DC {vcm} AC 1m
CL VOUT 0 {cl} m=1
V_S0 s[0] 0 0
V_S1 s[1] 0 0
V_S2 s[2] 0 0
V_S3 s[3] 0 0
V_S4 s[4] 0 0
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}
* std cells at top level (an include inside the DUT netlist is nested in the subckt and invisible to
*+ the sub-blocks)
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param ib=CACE{ib}
.param vdd=CACE{vdd}
.param vcm=CACE{vcm}
.param gain_tap=CACE{gain_tap=0}





.control
set num_threads=CACE{jobs}
save all

set tap = CACE{gain_tap=0}
set vdd = CACE{vdd}

alter @v_s0[dc] = 0
alter @v_s1[dc] = 0
alter @v_s2[dc] = 0
alter @v_s3[dc] = 0
alter @v_s4[dc] = 0

if ($tap = 1)
  alter @v_s0[dc] = $vdd
end
if ($tap = 2)
  alter @v_s1[dc] = $vdd
end
if ($tap = 3)
  alter @v_s2[dc] = $vdd
end
if ($tap = 4)
  alter @v_s3[dc] = $vdd
end
if ($tap = 5)
  alter @v_s4[dc] = $vdd
end

let target_lin = 2^($tap)
let vin_amp = 0.2 / target_lin

alter @v_in sin = [ CACE{vcm} $&vin_amp 1k ]

tran 7.8125u 10m 2m 7.8125u

set specwindow=none
linearize v(VOUT)
fft v(VOUT)

let nc = floor(2 * (length(v(VOUT)) - 1) / 128 + 0.5)
let mag_f = mag(v(VOUT))
let h1 = mag_f[nc]
let h2 = mag_f[2*nc]
let h3 = mag_f[3*nc]
let hsq = 0
let k = 2
while k <= 9
  let hsq = hsq + mag_f[k*nc]^2
  let k = k + 1
end
let thd = sqrt(hsq) / h1
let VO1 = h1
let THD_DB = 20 * log10(thd)
let THD_PCT = thd
let HD2_DB = 20 * log10(h2 / h1)
let HD3_DB = 20 * log10(h3 / h1)

let cace_THD_DB = THD_DB
let cace_THD_PCT = THD_PCT
let cace_HD2_DB = HD2_DB
let cace_HD3_DB = HD3_DB
let cace_VO1 = VO1

echo $&cace_THD_DB $&cace_THD_PCT $&cace_HD2_DB $&cace_HD3_DB $&cace_VO1 > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
