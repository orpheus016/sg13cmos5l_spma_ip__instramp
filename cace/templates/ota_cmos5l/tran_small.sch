** sch_path: cace/templates/ota_cmos5l/tran_small.sch
**.subckt tran_small
x1 VSS I_B VDD OUT3 VINP3 OUT3 ota_cmos5l
C1 OUT3 0 {cl} m=1
I0 I_B VSS {ib}
V1 VDD VSS {vdd}
V2 VSS 0 0
V3 VINP3 VSS {vicm}
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param ib=CACE{ib}
.param vdd=CACE{vdd}
.param vicm=CACE{vcm}
.param vid=0





.control
set num_threads=CACE{jobs}
save all
* small step vcm-50mV -> vcm+50mV on the follower
let vlo = CACE{vcm} - 0.05
let vhi = CACE{vcm} + 0.05
alter @v3[pulse] = [ $&vlo $&vhi 20n 1n 1n 500n 1.2u ]
tran 0.1n 1.2u
let v_ins = v(vinp3)
let v_outs = v(out3)
let vmid = CACE{vcm}
let v10 = vlo + 0.1*(vhi-vlo)
let v90 = vlo + 0.9*(vhi-vlo)
let vs1 = vhi - 0.01*(vhi-vlo)
let vs01 = vhi - 0.001*(vhi-vlo)
meas tran t_in50 when v_ins=$&vmid rise=1
meas tran t_out10 when v_outs=$&v10 rise=1
meas tran t_out50 when v_outs=$&vmid rise=1
meas tran t_out90 when v_outs=$&v90 rise=1
let T_DELAY = t_out50 - t_in50
let T_RISE = t_out90 - t_out10
meas tran v_peak max v_outs from=20n to=300n
let OVERSHOOT = (v_peak - vhi) / (vhi - vlo)
meas tran t_set1 when v_outs=$&vs1 cross=last from=20n to=500n
let TS_1PCT = t_set1 - 20n
meas tran t_set01 when v_outs=$&vs01 cross=last from=20n to=500n
let TS_01PCT = t_set01 - 20n
echo $&T_DELAY $&T_RISE $&OVERSHOOT $&TS_1PCT $&TS_01PCT > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc======================================================="


**** end user architecture code
**.ends

* expanding   symbol:  ota_cmos5l.sym # of pins=6
** sym_path: xschem/output_buffer/ota_cmos5l.sym
** sch_path: xschem/output_buffer/ota_cmos5l.sch
.subckt ota_cmos5l VSS IBIAS VDD VINN VINP VOUT
*.iopin IBIAS
*.iopin VDD
*.iopin VSS
*.iopin VOUT
*.iopin VINP
*.iopin VINN
XM6 IBIAS IBIAS VDD VDD sg13_lv_pmos w={wbias} l={lbias} ng=1 m={m6} mm_ok=1
XM7 net1 IBIAS VDD VDD sg13_lv_pmos w={wbias} l={lbias} ng=1 m={m7} mm_ok=1
XM8 VOUT IBIAS VDD VDD sg13_lv_pmos w={wbias} l={lbias} ng=1 m={m8} mm_ok=1
XM1 net2 VINN net1 VDD sg13_lv_pmos w={winpair} l={linpair} ng=1 m=1 mm_ok=1
XM2 net3 VINP net1 VDD sg13_lv_pmos w={winpair} l={linpair} ng=1 m=1 mm_ok=1
XM3 net2 net2 VSS VSS sg13_lv_nmos w={wload} l={lload} ng=1 m=1 mm_ok=1
XM4 net3 net2 VSS VSS sg13_lv_nmos w={wload} l={lload} ng=1 m=1 mm_ok=1
XM5 VOUT net3 VSS VSS sg13_lv_nmos w={wcs} l={lcs} ng=1 m=1 mm_ok=1
XR1 net3 net4 VSS rhigh w=0.5e-6 l=1.95e-6 m=1 b=0 mm_ok=1
.save v(vinp)
.save v(vinn)
.save v(vout)
XC2 VOUT net4 cap_cmomi w=15e-6 l=15e-6 mmin=1 mmax=4 feed=double subblock=0 m=5 mm_ok=1
**** begin user architecture code


.param temp=27
.param lbias=0.15u wbias=0.15u
.param m6=1 m7=4 m8=8
.param linpair=3u winpair=20u
.param lload=5u wload=10u
.param lcs=3u wcs=20u
.param Cc=2p



**** end user architecture code
XC1 VOUT net4 cap_cmomi w=15e-6 l=15e-6 mmin=1 mmax=4 feed=double subblock=0 m=4 mm_ok=1
.ends

.GLOBAL VDD
.end
