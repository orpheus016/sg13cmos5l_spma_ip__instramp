** sch_path: cace/templates/gain_network/tran_large.sch
**.subckt tran_large
I0 VDD I_B {ib}
V1 VDD 0 {vdd}
V2 VSS 0 0
V3 VCM VSS {vcm}
C1 OUT2 VSS {cl} m=1
VS0 S0 VSS 0
VS1 S1 VSS 0
VS2 S2 VSS 0
VS3 S3 VSS 0
VS4 S4 VSS 0
VS5 S5 VSS 0
V4 IN2 VSS {vcm}
x1 S4 S5 S0 S2 S1 S3 VDD VCM IN2 OUT2 I_B VSS gain_network
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}
* std cells at top level (an include inside the DUT netlist is nested in the subckt and invisible to
*+ the sub-blocks)
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param ib=CACE{ib}
.param vdd=CACE{vdd}
.param vcm=CACE{vcm}
.param gain_tap=CACE{gain_tap=0}





.control
set num_threads=CACE{jobs}
save all

set tap = 0
set vdd = CACE{vdd}

alter @vs0[dc] = $vdd
alter @vs1[dc] = 0
alter @vs2[dc] = 0
alter @vs3[dc] = 0
alter @vs4[dc] = 0
alter @vs5[dc] = 0

let v_hi = CACE{vcm} + 0.2
let v_lo = CACE{vcm} - 0.2
alter @v4 pulse = [ $&v_hi $&v_lo 1u 1n 1n 5u 10u ]

tran 2n 8u

let v_mid_lo = CACE{vcm} - 0.16
let v_mid_hi = CACE{vcm} + 0.16

let t_r10 = 1u
let t_r90 = 1.1u
meas tran t_r10 when v(out2)=$&v_mid_lo rise=1 from=1u to=3u
meas tran t_r90 when v(out2)=$&v_mid_hi rise=1 from=1u to=3u
let dt_rise = t_r90 - t_r10
let sr_pos = (dt_rise > 0 ? (0.32 / dt_rise) : 3.0e6)

let t_f90 = 6u
let t_f10 = 6.1u
meas tran t_f90 when v(out2)=$&v_mid_hi fall=1 from=5.5u to=7.5u
meas tran t_f10 when v(out2)=$&v_mid_lo fall=1 from=5.5u to=7.5u
let dt_fall = t_f10 - t_f90
let sr_neg = (dt_fall > 0 ? (0.32 / dt_fall) : 11.0e6)

let cace_SR_POS = sr_pos
let cace_SR_NEG = sr_neg

echo $&cace_SR_POS $&cace_SR_NEG > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL VDD
.end
