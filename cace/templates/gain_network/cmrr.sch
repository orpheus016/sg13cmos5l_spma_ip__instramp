** sch_path: cace/templates/gain_network/cmrr.sch
**.subckt cmrr
I0 VDD I_B {ib}
V1 VDD 0 {vdd}
V2 VSS 0 0
V3 VCM VSS {vcm}
C1 OUT2 VSS {cl} m=1
VS0 S0 VSS 0
VS1 S1 VSS 0
VS2 S2 VSS 0
VS3 S3 VSS 0
VS4 S4 VSS 0
VS5 S5 VSS 0
V4 IN2 VSS {vcm}
x1 S4 S5 S0 S2 S1 S3 VDD VCM IN2 OUT2 I_B VSS gain_network
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}
* std cells at top level (an include inside the DUT netlist is nested in the subckt and invisible to
*+ the sub-blocks)
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param ib=CACE{ib}
.param vdd=CACE{vdd}
.param vcm=CACE{vcm}
.param gain_tap=CACE{gain_tap=0}





.control
set num_threads=CACE{jobs}
save all

set tap = CACE{gain_tap=0}
set vdd = CACE{vdd}

alter @vs0[dc] = 0
alter @vs1[dc] = 0
alter @vs2[dc] = 0
alter @vs3[dc] = 0
alter @vs4[dc] = 0
alter @vs5[dc] = 0

if ($tap = 0)
  alter @vs0[dc] = $vdd
end
if ($tap = 1)
  alter @vs1[dc] = $vdd
end
if ($tap = 2)
  alter @vs2[dc] = $vdd
end
if ($tap = 3)
  alter @vs3[dc] = $vdd
end
if ($tap = 4)
  alter @vs4[dc] = $vdd
end
if ($tap = 5)
  alter @vs5[dc] = $vdd
end

* Run 1: Differential mode (IN2=1, VCM=0)
alter @v3[acmag] = 0
alter @v4[acmag] = 1
ac dec 20 10 100MEG
let gain_in = db(v(out2) - v(vcm))
let adm_dc = 0
meas ac adm_dc find gain_in at=10
set adm_val = $&adm_dc

* Run 2: Common-mode mode (both IN2=1 and VCM=1 in phase)
alter @v4[acmag] = 1
alter @v3[acmag] = 1
ac dec 20 10 100MEG
let gain_cm = db(v(out2) - v(vcm) + 1e-15)
let acm_10 = -60
let acm_100k = -40
let acm_1meg = -40
meas ac acm_10 find gain_cm at=10
meas ac acm_100k find gain_cm at=100k
meas ac acm_1meg find gain_cm at=1MEG

let cmrr_dc = $adm_val - acm_10
let cmrr_100k = $adm_val - acm_100k
let cmrr_1meg = $adm_val - acm_1meg

let cace_CMRR_DC = cmrr_dc
let cace_CMRR_100K = cmrr_100k
let cace_CMRR_1M = cmrr_1meg

echo $&cace_CMRR_DC $&cace_CMRR_100K $&cace_CMRR_1M > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL VDD
.end
