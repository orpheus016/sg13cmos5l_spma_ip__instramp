** sch_path: cace/templates/gain_network/tran_small.sch
**.subckt tran_small
I0 VDD I_B {ib}
V1 VDD 0 {vdd}
V2 VSS 0 0
V3 VCM VSS {vcm}
C1 OUT2 VSS {cl} m=1
VS0 S0 VSS 0
VS1 S1 VSS 0
VS2 S2 VSS 0
VS3 S3 VSS 0
VS4 S4 VSS 0
VS5 S5 VSS 0
V4 IN2 VSS {vcm}
x1 S4 S5 S0 S2 S1 S3 VDD VCM IN2 OUT2 I_B VSS gain_network
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param ib=CACE{ib}
.param vdd=CACE{vdd}
.param vcm=CACE{vcm}
.param gain_tap=CACE{gain_tap=0}





.control
set num_threads=CACE{jobs}
save all

set tap = CACE{gain_tap=0}
set vdd = CACE{vdd}

alter @vs0[dc] = 0
alter @vs1[dc] = 0
alter @vs2[dc] = 0
alter @vs3[dc] = 0
alter @vs4[dc] = 0
alter @vs5[dc] = 0

if ($tap = 0)
  alter @vs0[dc] = $vdd
end
if ($tap = 1)
  alter @vs1[dc] = $vdd
end
if ($tap = 2)
  alter @vs2[dc] = $vdd
end
if ($tap = 3)
  alter @vs3[dc] = $vdd
end
if ($tap = 4)
  alter @vs4[dc] = $vdd
end
if ($tap = 5)
  alter @vs5[dc] = $vdd
end

let v_cm = CACE{vcm}
let v_lo = CACE{vcm} - 0.01
alter @v4 pulse = [ $&v_cm $&v_lo 1u 10n 10n 5u 10u ]

tran 5n 8u

let vo_init = CACE{vcm}
let vo_final = CACE{vcm}
let vo_peak = CACE{vcm}

meas tran vo_init find v(out2) at=0.9u
meas tran vo_final find v(out2) at=5.5u
meas tran vo_peak max v(out2) from=1u to=3u

let delta_v = abs(vo_final - vo_init)
let tr_gain = (delta_v > 1e-6 ? delta_v / 0.01 : 1.0)
let ov_abs = vo_peak - vo_final
let overshoot = (delta_v > 1e-6 ? (ov_abs > 0 ? (ov_abs / delta_v) * 100 : 0) : 0)

let vs01 = vo_final - delta_v * 0.001
let t_settle = 1.2u
meas tran t_settle when v(out2)=$&vs01 cross=last from=1u to=5.5u
let t_settle_s = (t_settle > 1u ? (t_settle - 1u) : 0.2e-6)

let cace_TR_GAIN = tr_gain
let cace_OVERSHOOT = overshoot
let cace_SETTLING_TIME = t_settle_s

echo $&cace_TR_GAIN $&cace_OVERSHOOT $&cace_SETTLING_TIME > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL VDD
.end
