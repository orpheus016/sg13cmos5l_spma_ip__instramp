** sch_path: cace/templates/gain_network/noise.sch
**.subckt noise
I0 VDD I_B {ib}
V1 VDD 0 {vdd}
V2 VSS 0 0
V3 VCM VSS {vcm}
C1 OUT2 VSS {cl} m=1
VS0 S0 VSS 0
VS1 S1 VSS 0
VS2 S2 VSS 0
VS3 S3 VSS 0
VS4 S4 VSS 0
VS5 S5 VSS 0
V4 IN2 VSS {vcm}
x1 S4 S5 S0 S2 S1 S3 VDD VCM IN2 OUT2 I_B VSS gain_network
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}
* std cells at top level (an include inside the DUT netlist is nested in the subckt and invisible to
*+ the sub-blocks)
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param ib=CACE{ib}
.param vdd=CACE{vdd}
.param vcm=CACE{vcm}
.param gain_tap=CACE{gain_tap=0}





.control
set num_threads=CACE{jobs}
save all
destroy all

set tap = CACE{gain_tap=0}
set vdd = CACE{vdd}

alter @vs0[dc] = 0
alter @vs1[dc] = 0
alter @vs2[dc] = 0
alter @vs3[dc] = 0
alter @vs4[dc] = 0
alter @vs5[dc] = 0

if ($tap = 0)
  alter @vs0[dc] = $vdd
end
if ($tap = 1)
  alter @vs1[dc] = $vdd
end
if ($tap = 2)
  alter @vs2[dc] = $vdd
end
if ($tap = 3)
  alter @vs3[dc] = $vdd
end
if ($tap = 4)
  alter @vs4[dc] = $vdd
end
if ($tap = 5)
  alter @vs5[dc] = $vdd
end

alter @v4[acmag] = 1
noise v(out2) v4 dec 20 10 100MEG
alter @v4[acmag] = 0

setplot noise1

let inoise_total_uv = noise2.inoise_total * 1e6
let onoise_total_uv = noise2.onoise_total * 1e6
let irn_nv = noise1.inoise_spectrum * 1e9
let orn_nv = noise1.onoise_spectrum * 1e9

let gain_lf = noise1.onoise_spectrum[0] / noise1.inoise_spectrum[0]
let inoise_eq_uv = onoise_total_uv / gain_lf

let irn_10 = irn_nv[0]
let irn_100 = irn_nv[20]
let irn_1k = irn_nv[40]
let irn_10k = irn_nv[60]

let cace_IRN_10 = irn_10 * 1e-9
let cace_IRN_100 = irn_100 * 1e-9
let cace_IRN_1K = irn_1k * 1e-9
let cace_IRN_10K = irn_10k * 1e-9
let cace_ORN_1K = orn_nv[40] * 1e-9
let cace_ONOISE_TOT = onoise_total_uv * 1e-6
let cace_INOISE_EQ = inoise_eq_uv * 1e-6

echo $&cace_IRN_10 $&cace_IRN_100 $&cace_IRN_1K $&cace_IRN_10K $&cace_ORN_1K $&cace_ONOISE_TOT $&cace_INOISE_EQ
+ > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL VDD
.end
