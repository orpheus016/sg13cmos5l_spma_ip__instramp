** sch_path: cace/templates/gain_network/thd.sch
**.subckt thd
I0 VDD I_B {ib}
V1 VDD 0 {vdd}
V2 VSS 0 0
V3 VCM VSS {vcm}
C1 OUT2 VSS {cl} m=1
VS0 S0 VSS 0
VS1 S1 VSS 0
VS2 S2 VSS 0
VS3 S3 VSS 0
VS4 S4 VSS 0
VS5 S5 VSS 0
V4 IN2 VSS {vcm}
x1 S4 S5 S0 S2 S1 S3 VDD VCM IN2 OUT2 I_B VSS gain_network
**** begin user architecture code



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{rcorner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_typ
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_tt
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSCAP.lib moscap_tt

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





.param temp=CACE{temperature}
.param cl=CACE{cl}
.param ib=CACE{ib}
.param vdd=CACE{vdd}
.param vcm=CACE{vcm}
.param gain_tap=CACE{gain_tap=0}





.control
set num_threads=CACE{jobs}
save all

set tap = CACE{gain_tap=0}
set vdd = CACE{vdd}

alter @vs0[dc] = 0
alter @vs1[dc] = 0
alter @vs2[dc] = 0
alter @vs3[dc] = 0
alter @vs4[dc] = 0
alter @vs5[dc] = 0

if ($tap = 0)
  alter @vs0[dc] = $vdd
end
if ($tap = 1)
  alter @vs1[dc] = $vdd
end
if ($tap = 2)
  alter @vs2[dc] = $vdd
end
if ($tap = 3)
  alter @vs3[dc] = $vdd
end
if ($tap = 4)
  alter @vs4[dc] = $vdd
end
if ($tap = 5)
  alter @vs5[dc] = $vdd
end

let target_lin = 2^($tap)
let vin_amp = 0.2 / target_lin

alter @v4 sin = [ CACE{vcm} $&vin_amp 1k ]

tran 7.8125u 10m 2m 7.8125u

set specwindow=none
linearize v(out2)
fft v(out2)

let nc = floor(2 * (length(v(out2)) - 1) / 128 + 0.5)
let mag_f = mag(v(out2))
let h1 = mag_f[nc]
let h2 = mag_f[2*nc]
let h3 = mag_f[3*nc]
let hsq = 0
let k = 2
while k <= 9
  let hsq = hsq + mag_f[k*nc]^2
  let k = k + 1
end
let thd = sqrt(hsq) / h1
let VO1 = h1
let THD_DB = 20 * log10(thd)
let THD_PCT = thd
let HD2_DB = 20 * log10(h2 / h1)
let HD3_DB = 20 * log10(h3 / h1)

let cace_THD_DB = THD_DB
let cace_THD_PCT = THD_PCT
let cace_HD2_DB = HD2_DB
let cace_HD3_DB = HD3_DB
let cace_VO1 = VO1

echo $&cace_THD_DB $&cace_THD_PCT $&cace_HD2_DB $&cace_HD3_DB $&cace_VO1 > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL VDD
.end
